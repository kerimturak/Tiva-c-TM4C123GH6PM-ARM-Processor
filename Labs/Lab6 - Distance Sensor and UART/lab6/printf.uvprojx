# Keil uVision project printf.uvprojx, settings and files
target printf (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: printf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s main.c UART.c
